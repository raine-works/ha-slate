# Replace the stock boot script with the RAUC A/B slot selector.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
